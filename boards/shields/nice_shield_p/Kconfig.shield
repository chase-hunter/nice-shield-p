## boards/shields/nice_shield_p/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_SHIELD_P
    def_bool $(shields_list_contains,nice_shield_p)
```
